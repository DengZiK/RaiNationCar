# Keil uVision project NatonalCarSet.uvprojx, settings and files
target NatonalCarSet (6240000::V6.24::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NatonalCarSet +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -mfpu=fpv4-sp-d16 -mfloat-abi=hard
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../user/app/app_config;../user/bsp/remote;../user/bsp/motor;../user/bsp/valve;../user/bsp/imu;../user/bsp/ws2815;../user/algo/pid;../user/algo/vofa;../user/app/chassis;../user/app/lift;../user/app/watchdog;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group User/APP/chassis
    ../user/app/chassis/: chassis.c chassis.h
  group User/APP/lift
    ../user/app/lift/: lift.c lift.h
  group User/APP/watchdog
    ../user/app/watchdog/: watchdog.c watchdog.h
  group User/APP/app_config
    ../user/app/app_config/: app_config.h
  group User/BSP/motor
    ../user/bsp/motor/: motor.c motor.h
  group User/BSP/remote
    ../user/bsp/remote/: remote.c remote.h
  group User/BSP/valve
    ../user/bsp/valve/: valve.c valve.h
  group User/BSP/imu
    ../user/bsp/imu/: imu.c imu.h
  group User/BSP/ws2815
    ../user/bsp/ws2815/: ws2815.c ws2815.h
  group User/ALGO/pid
    ../user/algo/pid/: pid.c pid.h
  group User/ALGO/vofa
    ../user/algo/vofa/: vofa.c vofa.h
software components: CMSIS:CORE 6.1.1
